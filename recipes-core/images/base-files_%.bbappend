DISTRO_NAME = "Autot OS Poky-based"
DISTRO_VERSION = "0.1"
