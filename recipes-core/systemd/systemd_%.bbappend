PACKAGECINFIG:append = " networkd resolved"
