SYSTEMD_SERVICE:${PN} = "ssh.service"
SYSTEMD_AUTO_ENABLE:${PN} = "enable"
